# Keil uVision project midi-key.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: midi-key
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\src\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group main
    ./src/main/: main.c
  group board
    ./src/board/: sysclk.c pin_config.c
  group keyboard
    ./src/keyboard/: keyboard_task.c keyboard.c
  group usb
    ./src/usb/: pma.c usbd_core.c usbd_setup.c usbd_desc.c usbd_cdc_desc.c usbd_cdc.c
  group task
    ./src/task/: task.c
  group ::Device
    ./src/keyboard/: scan.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
